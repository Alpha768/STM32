# Keil uVision project USB_Tool.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USB_Tool +hex
  AfterMake: %karm\armcc\bin\fromelf.exe --bin -o  ..\..\Output\HD26.bin ..\..\Object\%l
  AfterMake: aes.exe  -e  ..\..\Output\HD26.bin  ..\..\Output\HD26.enc
  c flags: Optim=1
  c include: ..\..\Include;..\..\Include\USB;..\..\Include\UART;..\..\Include\SPI;..\..\Include\I2C;..\..\Include\PWM;..\..\Include\STM32F10x;..\..\Include\ADC;..\..\Include\LCD;..\..\Include\OLED;..\..\Include\Lw_oopc;..\..\Source;..\..\Include\Remoter
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./: STM32F10x.s
  group Initialisation
    ../../Source/: STM32_Init.c
  group Configuration
    ../../Include/USB/: usbcfg.h
  group Core
    ../../Source/: main.c SysTick.c Time.c Queue.c CRC32.c CRC16.c IO.c KEY.c Execute.c IAP.c USB.c Device.c AES.c Store.c MCU.c
  group USB
    ../../Source/USB/: cdcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group UART
    ../../Source/UART/: serial.c
  group SPI
    ../../Source/SPI/: SPI.c
  group PWM
    ../../Source/PWM/: PWM.c
  group ADC
    ../../Source/ADC/: ADC.c
  group Remoter
    ../../Source/Remoter/: IrSimulator.c
  group Store
    ../../Source/Store/: STM32F_Flash.c
  group Lw_oopc
    ../../Source/Lw_oopc/: Light.c lw_oopc.c Switch.c
  group OLED
    ../../Source/OLED/: oled.c
